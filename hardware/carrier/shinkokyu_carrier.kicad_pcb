# Repository Hi6to/shinkokyu

File README.md:

# シン呼吸 — 吸わなくても、気軽にひと息つける

たばこ休憩のように席を立つための **「口実・相手・休み方」** を、たばこを吸わない人にも渡す呼吸デバイスと、デスクトップアプリです。
くわえて吸う・吐くを気圧センサーで判定し、本体の LED と音、PC の画面の隅で育つキャラクター「火の子」で、ゆっくりした呼吸と休憩をうながします。

JPHACKS 2026 にチーム「こんにちは」（3人）で出場した作品を、Award Day に向けてポケットに入る本体に作り直した版です。

## 受賞（JPHACKS 2026）

| 賞 | 内容 |
|---|---|
| **Hack Day Audience Award**（札幌会場） | Hack Day 札幌会場の成果発表で、オーディエンス投票で選ばれた |
| **Award Finalist** | 全国約150チームから、Award Day（2026年11月15日、東京大学）に進んだ17チームの1つ |
| **インフィニオン テクノロジーズ ジャパン株式会社賞** | Award Day で授与されたスポンサー賞 |

Hack Day で提出した版：[jphacks/sp_2605](https://github.com/jphacks/sp_2605)

## できること

- **吸っている間だけ曲が進む本体**：Infineon の気圧センサー DPS368 と Seeed XIAO nRF52840 で吸う・吐くを判定し、LED の色と音（笛・泡・オルゴール）で呼吸をうながす
- **2人で使えるデスクトップアプリ**（Electron）：本体2台を同時に Bluetooth でつなぎ、画面の右下の「火の子」を一緒に育てる。本体の ▶ 長押しで、相手を休憩に誘える
- **休みどきの「理由の1行」**：続けて作業した時間や、作業のリズムの乱れから、休んでいい理由を出す
- **愚痴を「薪」にする**：声の基板（XIAO nRF52840 Sense）で録った声を、**PC の中だけで**文字にし（faster-whisper）、ローカルの LLM（sarashina2.2-3b / Ollama）で短い言葉にして火にくべる。**声も文字も PC の外に出さない**

## しくみ

```mermaid
flowchart LR
  subgraph 本体["本体（XIAO nRF52840）"]
    S[DPS368 気圧センサー] --> F[呼吸の判定<br/>firmware/shinkokyu]
    F --> L[LED・音]
  end
  subgraph 声の基板["声の基板（XIAO nRF52840 Sense）"]
    M[マイク 16kHz] --> A[IMA ADPCM 4bit<br/>約8KB/s]
  end
  subgraph PC["PC（Electron アプリ desktop/）"]
    W[web/retro.html<br/>Web Bluetooth] --> G[火の子・通知・理由の1行]
    V[sense-mic.js] --> T[faster-whisper small] --> O[Ollama sarashina2.2-3b] --> G
  end
  F -- BLE（Nordic UART）--> W
  A -- BLE（独自フレーム A5 5A）--> V
```

| 場所 | 中身 |
|---|---|
| [firmware/](firmware/) | 本体（`shinkokyu/`）と声の基板（`sense_mic/`）の Arduino プログラム、動作確認用のスケッチ |
| [desktop/](desktop/) | Electron アプリ。窓の管理、BLE の声の受信、音声認識と LLM の呼び出し（`voice/`） |
| [web/](web/) | アプリの中で表示する画面。Web Bluetooth で本体とつなぐ `device.js`、ゲームの画面 `retro.html` |
| [songs/](songs/) | 吸っている間に進む曲のデータ |
| [hardware/](hardware/) | KiCad の基板（`carrier/`・`carrier_b/`）、Python で作った外装（`enclosure/`）、3D プリント用の STL（`print/`） |
| [docs/](docs/) | 仕様、課題の整理、人物像、外装・部品表などの設計資料 |

**使った技術**：C++（Arduino / nRF52）、JavaScript（Electron 45、Web Bluetooth、Canvas）、Python（faster-whisper、KiCad の自動生成、manifold3d・trimesh での外装の形づくり）、Ollama、KiCad、3D プリント

## 担当

チーム3人のうち、本体の組み立て、ファームウェア、デスクトップアプリ、声の機能、3D プリント、発表スライドを担当しました。
（本体の形のたたき台とアンケートの作成はチームメンバー）

## 開発で解いた問題（例）

本番の前の数日で、実機で起きた不具合を、ログを取って原因を確かめてから直しました。

| 問題 | 原因 | 直し方 | 結果 |
|---|---|---|---|
| 窓を閉じて開き直したあと、録音しても文字にならない | 同じ本体への BLE 接続が2重にでき、古い接続にもデータが流れていた | 接続をモジュール全体の `Map` で1つに管理し、切断時にリスナーを外す（`web/device.js`） | 実機で解消を確認 |
| 2台つないでいると、録音の停止ボタンが画面に反映されないことがある | BLE が混んでいると、応答なしの書き込み（`REC 0`）が落ちる | 応答ありの書き込み＋2秒のタイムアウト＋3回まで再送の送信キュー。届かなくても、止めた時刻までの声で文字にする（`desktop/sense-mic.js`・`panel.html`） | 実機で解消を確認 |
| 声の基板が途中で止まると、録音が終わらない | 基板側からデータが来ない状態を検知していなかった | 3秒データが来なければ PC のマイクに切りかえる | 模擬テストで確認 |
| 録音を止めてから「薪」になるまで約60秒かかる | 音声認識モデルの読み込みと、LLM の初回ロード | 起動5秒後に先読み（ウォームアップ）、`cpu_threads` の調整、LLM を `keep_alive` で常駐、結果をすぐ通知 | **約60秒 → 約3.4秒** |
| 起動直後、PC から音が出ないことがある | 画面が top-level await のモジュールで、`did-finish-load` の時点ではまだ API がない | API ができるまで最大15秒待ってから呼ぶ `callReady()` を用意 | 実機で解消を確認 |

## 課題の確かめ方（事前アンケート 60件：学生47人・社会人13人）

- 席を**立てるのに気軽には立てない**学生が **28%**
- 休まなかった理由がある学生の **40%** が、「周りの目」「きっかけがない」など**人ときっかけの理由**を選んだ
- 休憩でスマホを見る学生の **45%** が「休めていない」と答えた
- くわえることに抵抗がある学生の **68%** が「人前でくわえるのが恥ずかしい」を選んだ

この結果から、「休む口実」「一緒に休む相手」「スマホを見ない休み方」の3つを柱にしました（[docs/PRODUCT.md](docs/PRODUCT.md)、[docs/PERSONA.md](docs/PERSONA.md)）。

## 動かし方

アプリの起動は [desktop/README.md](desktop/README.md)、本体への書きこみは [firmware/README.md](firmware/README.md) にあります。

## 補足

- 開発では Claude Code（AI のコーディング支援）を使いました。仕様の決定、実機での確認、不具合の切り分けは自分で行っています
- このリポジトリは、面接などで見てもらうために、チームの開発用リポジトリから設計資料とコードを選んでまとめたものです。アンケートの個別の回答や連絡先は入れていません

## KiCad design hardware/carrier/shinkokyu_carrier.kicad_pcb

File hardware/carrier/README.md:

# XIAO nRF52840 を載せる基板（KiCad 10）

設計の考え方は [docs/PCB_DESIGN.md](../../docs/PCB_DESIGN.md)、部品表は [docs/PCB_BOM.md](../../docs/PCB_BOM.md) を見てください。

| ファイル | 中身 |
|---|---|
| [shinkokyu_carrier_schematic.pdf](shinkokyu_carrier_schematic.pdf) | 回路図（PDF） |
| [images/](images/) | 基板の絵（3D の表・裏、銅と印刷の PDF） |
| [jlcpcb/](jlcpcb/) | JLCPCB に送るファイル（ガーバーの zip・部品表・部品の位置） |
| shinkokyu_carrier.kicad_pro / .kicad_sch / .kicad_pcb | KiCad のプロジェクト・回路図・基板 |
| lib/ | 自作の記号（XIAO nRF52840・DPS368）と型（フットプリント） |
| scripts/ | 回路図・基板・部品表を作るプログラム |

## A版と B版

同じプログラムで2つの版を作ります（環境変数 `VARIANT`）。

| 版 | フォルダ | XIAO |
|---|---|---|
| A | このフォルダ（hardware/carrier） | 自分ではんだ付け（窓から裏の BAT+ に線） |
| B | [hardware/carrier_b](../carrier_b/) | JLCPCB が付ける（裏の BAT+・GND も機械ではんだ） |

自作の記号と型（lib/）は A版・B版で共通です。

## 作り直し方

部品とつながりは `scripts/design.py`、置き場所と基板の形は `scripts/layout.py` にまとめてあります。次の1行で、回路図から JLCPCB に送るファイルまで全部作り直せます。

```bash
bash hardware/carrier/scripts/build.sh A B
```

中では次の順に動きます（KiCad についている Python と、numpy・scipy・pypdfium2・Pillow が入ったふつうの Python を使う）。

| プログラム | すること |
|---|---|
| make_lib.py | 自作の記号と型 |
| make_sch.py・check_sch.py | 回路図、ERC、つながりの照合、回路図の PDF |
| make_pcb.py | 部品を置いた基板と、端子の形（pads_A.json など） |
| route.py | 配線（routes_A.json など）。引けない線は、邪魔な線を外して引き直す |
| apply_routes.py | 配線と GND のベタを基板に入れる。ほかとつながらない GND があれば書き出し、`route.py repair` で線を足して作り直す |
| make_bom.py・make_fab.py | JLCPCB の部品表・ガーバー・部品の位置・画像 |
| verify_xiao.py | XIAO の公式の基板データを重ねて、端子ごとの信号・裏の端子の真下・USB-C の口を確かめる |

最後に DRC（基板の自動チェック）を、回路図との照合つきで行います。

```bash
"$HOME/AppData/Local/Programs/KiCad/10.0/bin/kicad-cli.exe" pcb drc --schematic-parity --severity-all -o drc.rpt shinkokyu_carrier.kicad_pcb
```

2026/10/21 の結果（A版・B版とも）：エラー 0。警告は「KiCad の部品ライブラリの設定がない」と「端子の枠の印刷が基板の縁にかかる」だけ。

KiCad を初めて開くと「グローバルライブラリの設定」を聞かれます。「デフォルトのグローバルライブラリをコピー」を選んでください。

Parts:
C1, C2: 10uF; C_0603_1608Metric; LCSC C19702
C3, C4, C5: 100nF; C_0402_1005Metric; LCSC C1525
D1: M7; D_SMA; LCSC C95872
D2: B5819W; D_SOD-123; LCSC C8598
J1: BATTERY; PinHeader_1x02_P2.00mm_Vertical; JLC 手で付ける
J2: PWR_SW; PinHeader_1x02_P2.54mm_Vertical; JLC 手で付ける
J3: SPEAKER; PinHeader_1x02_P2.54mm_Vertical; JLC 手で付ける
J4: AMP_EXT; PinHeader_1x07_P2.54mm_Vertical; JLC 手で付ける
J5: I2C_EXT; PinHeader_1x04_P2.54mm_Vertical; JLC 手で付ける
J6: IO; PinHeader_1x06_P2.54mm_Vertical; JLC 手で付ける
J7: TAB_WIRE; PinHeader_1x04_P2.54mm_Vertical; JLC 手で付ける
JP1: Q1_BYPASS; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; JLC 手で付ける
JP2: PWR_BYPASS; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; JLC 手で付ける
JP3: ADDR_0x76; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; JLC 手で付ける
Q1: AO3401A; SOT-23; LCSC C15127
R1, R2, R3: 4.7k; R_0402_1005Metric; LCSC C25900
SW1: NEXT; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
SW2: VOL+; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
SW3: VOL-; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
TP1: XIAO_BAT+; TestPoint_Pad_1.5x1.5mm; JLC 手で付ける
TP2: 5V; TestPoint_Pad_D1.5mm; JLC 手で付ける
U1: XIAO nRF52840; XIAO_nRF52840_Hybrid; JLC 手で付ける
U2: MAX98357AETE+T; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm; LCSC C910544
U3: DPS368XTSA1; Infineon_PG-VLGA-8-2; LCSC C3232508

Connections:
+3V3: C4.1, C5.1, J5.1, J7.1, R1.1, R2.1, U1.12 (3V3), U3.2 (CSB), U3.6 (VDDIO), U3.8 (VDD)
/AMP_EN: R3.1, U1.8 (D7)
/BAT_RAW: J1.1, JP1.1 (A), Q1.3 (D)
/BTN_DOWN: J6.4, SW3.1, U1.3 (D2)
/BTN_NEXT: J6.2, SW1.1, U1.1 (D0)
/BTN_UP: J6.3, SW2.1, U1.2 (D1)
/DPS_SDO: JP3.1 (A), U3.5 (SDO)
/GAIN: J4.4, U2.2 (GAIN_SLOT)
/I2S_BCLK: J4.2, U1.9 (D8/SCK), U2.16 (BCLK)
/I2S_DIN: J4.3, U1.11 (D10/MOSI), U2.1 (DIN)
/I2S_LRCLK: J4.1, U1.10 (D9/MISO), U2.14 (LRCLK)
/IO6: J6.6, U1.7 (D6)
/PIEZO: J6.5, U1.4 (D3)
/SCL: J5.4, J7.4, R2.2, U1.6 (D5/SCL), U3.4 (SCK)
/SDA: J5.3, J7.3, R1.2, U1.5 (D4/SDA), U3.3 (SDI)
/SD_MODE: J4.5, R3.2, U2.4 (~SD_MODE)
/SPK_N: J3.2, U2.10 (OUTN)
/SPK_P: J3.1, U2.9 (OUTP)
/VAMP: C1.1, C2.1, C3.1, D1.1 (K), D2.1 (K), J4.7, U2.7 (VDD), U2.8 (VDD)
/VBAT: D2.2 (A), J2.2, JP2.2 (B), TP1.1
/VBAT_Q: J2.1, JP1.2 (B), JP2.1 (A), Q1.2 (S)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.2, J4.6, J5.2, J6.1, J7.2, JP3.2 (B), Q1.1 (G), SW1.2, SW2.2, SW3.2, U1.13 (GND), U2.3 (GND), U2.11 (GND), U2.15 (GND), U2.17 (PAD), U3.1 (GND), U3.7 (GND)
VBUS: D1.2 (A), TP2.1, U1.14 (5V)

Notes on the sheet:
マイコン：XIAO nRF52840（自分ではんだ付けする）
電源：電池・逆接続の保護・アンプの電源
アンプ：MAX98357A（I2S）とスピーカー
気圧センサー：DPS368（基板のはみ出し部分＝切り離せる）
I2C の本体側（プルアップ・外付け用の端子）
ボタン・予備の端子
D0 曲送り / D1 音量＋ / D2 音量− （ボタンの反対側は GND。XIAO の中のプルアップを使う）
D3 圧電ブザー（アンプが動かないときの予備） / D6 予備
D4・D5 気圧センサー（I2C） / D7 アンプのオン・オフ
D8〜D10 アンプへの音の信号（I2S）。nRF52840 はピンをプログラムで入れ替えられる
電池の＋（VBAT）は、基板の窓から XIAO の裏の BAT+ に線でつなぐ（TP1）
Q1：電池の＋−を逆につないでも壊れないようにする。JP1 は Q1 が動かないときだけつなぐ
JP2：はじめからつながっている。電源スイッチを付けるときは切って、J2 にスイッチをつなぐ
D1・D2：USB の 5V と電池の高い方からアンプに電気を送る（電池なしでも USB だけで試せる）
SD_MODE：D7 を高くすると鳴る（左の音）、低くすると止まる。R3 は SD_MODE を守る抵抗
音量（GAIN）：何もつながない＝9dB（音量はプログラムで変える）。GAIN と SD_MODE は J4 の穴にも出してある
J4：アンプが動かないとき、外付けのアンプ基板を同じ並びでつなぐ
SDO は何もつながない＝アドレス 0x77。JP3 をつなぐと 0x76。CSB は 3V3（I2C を使う）
切り離したら、J7 と本体側の J5 を4本の線でつなぐ（3V3・GND・SDA・SCL）
SW1〜SW3：上から押す小さなボタン（TS-1187A、5.1mm 角・高さ 1.5mm）
J6：普通のボタンを線でつなぐとき・圧電ブザー（D3）・予備（D6）
シン呼吸 ポータブル版：XIAO nRF52840 を載せる基板（回路図・A版：XIAO は自分ではんだ付け）

Board: 2 copper layers, 67.5 x 20.5 mm, 29 parts (1 on the bottom side), 23 nets.

File hardware/carrier/jlcpcb/BOM_JLCPCB.csv:

Comment,Designator,Footprint,LCSC
10uF,"C1,C2",C_0603_1608Metric,C19702
100nF,"C3,C4,C5",C_0402_1005Metric,C1525
M7,D1,D_SMA,C95872
B5819W,D2,D_SOD-123,C8598
AO3401A,Q1,SOT-23,C15127
4.7k,"R1,R2,R3",R_0402_1005Metric,C25900
TS-1187A-B-A-B,"SW1,SW2,SW3",SW_Push_1P1T_XKB_TS-1187A,C318884
MAX98357AETE+T,U2,TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm,C910544
DPS368XTSA1,U3,Infineon_PG-VLGA-8-2,C3232508

## Code that names these connections

File hardware/carrier/scripts/design.py:

# シン呼吸 ポータブル版：XIAO nRF52840 を載せる基板の部品とつながり
# 回路図（make_sch.py）と基板（make_pcb.py）は、どちらもこのファイルから作る。

# (記号, 型, 値, JLCPCB の部品番号, 付けない(DNP), 端子→ネット, メモ)
PARTS = {
    # ---- マイコン（自分ではんだ付け）
    "U1": dict(sym="shinkokyu:XIAO_nRF52840", fp="shinkokyu:XIAO_nRF52840_Hybrid", value="XIAO nRF52840",
               lcsc=None, hand=True,
               pins={"1": "BTN_NEXT", "2": "BTN_UP", "3": "BTN_DOWN", "4": "PIEZO", "5": "SDA", "6": "SCL",
                     "7": "IO6", "8": "AMP_EN", "9": "I2S_BCLK", "10": "I2S_LRCLK", "11": "I2S_DIN",
                     "12": "+3V3", "13": "GND", "14": "VBUS"},
               note="自分ではんだ付けする"),
    # ---- アンプ
    "U2": dict(sym="Audio:MAX98357A", fp="Package_DFN_QFN:TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm",
               value="MAX98357AETE+T", lcsc="C910544",
               pins={"1": "I2S_DIN", "2": "GAIN", "3": "GND", "4": "SD_MODE", "7": "VAMP", "8": "VAMP",
                     "9": "SPK_P", "10": "SPK_N", "11": "GND", "14": "I2S_LRCLK", "15": "GND", "16": "I2S_BCLK",
                     "17": "GND"}),
    "C1": dict(sym="Device:C", fp="Capacitor_SMD:C_0603_1608Metric", value="10uF", lcsc="C19702",
               pins={"1": "VAMP", "2": "GND"}),
    "C2": dict(sym="Device:C", fp="Capacitor_SMD:C_0603_1608Metric", value="10uF", lcsc="C19702",
               pins={"1": "VAMP", "2": "GND"}),
    "C3": dict(sym="Device:C", fp="Capacitor_SMD:C_0402_1005Metric", value="100nF", lcsc="C1525",
               pins={"1": "VAMP", "2": "GND"}),
    "R3": dict(sym="Device:R", fp="Resistor_SMD:R_0402_1005Metric", value="4.7k", lcsc="C25900",
               pins={"1": "AMP_EN", "2": "SD_MODE"}, note="SD_MODE を守る直列の抵抗"),
    "J3": dict(sym="Connector_Generic:Conn_01x02", fp="Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical",
               value="SPEAKER", lcsc=None, hand=True, pins={"1": "SPK_P", "2": "SPK_N"}, note="スピーカーの線"),
    "J4": dict(sym="Connector_Generic:Conn_01x07", fp="Connector_PinHeader_2.54mm:PinHeader_1x07_P2.54mm_Vertical",
               value="AMP_EXT", lcsc=None, hand=True,
               pins={"1": "I2S_LRCLK", "2": "I2S_BCLK", "3": "I2S_DIN", "4": "GAIN", "5": "SD_MODE", "6": "GND",
                     "7": "VAMP"},
               note="予備：外付けのアンプ基板（Adafruit と同じ並び）"),
    # ---- 電源
    "J1": dict(sym="Connector_Generic:Conn_01x02", fp="Connector_PinHeader_2.00mm:PinHeader_1x02_P2.00mm_Vertical",
               value="BATTERY", lcsc=None, hand=True, pins={"1": "BAT_RAW", "2": "GND"},
               note="電池の線（2.0mm 間隔＝PH コネクタも付けられる）"),
    "Q1": dict(sym="Transistor_FET:AO3401A", fp="Package_TO_SOT_SMD:SOT-23", value="AO3401A", lcsc="C15127",
               pins={"1": "GND", "2": "VBAT_Q", "3": "BAT_RAW"}, note="電池の＋−を逆につないだときに守る"),
    "JP1": dict(sym="Jumper:SolderJumper_2_Open", fp="Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm",
                value="Q1_BYPASS", lcsc=None, pins={"1": "BAT_RAW", "2": "VBAT_Q"},
                note="予備：Q1 が動かないときだけ、はんだでつなぐ"),
    "JP2": dict(sym="Jumper:SolderJumper_2_Bridged", fp="Jumper:SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",
                value="PWR_BYPASS", lcsc=None, pins={"1": "VBAT_Q", "2": "VBAT"},
                note="はじめからつながっている。電源スイッチを付けるときは切る"),
    "J2": dict(sym="Connector_Generic:Conn_01x02", fp="Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical",
               value="PWR_SW", lcsc=None, hand=True, pins={"1": "VBAT_Q", "2": "VBAT"},
               note="予備：電源スイッチの線"),
    "TP1": dict(sym="Connector:TestPoint", fp="TestPoint:TestPoint_Pad_1.5x1.5mm", value="XIAO_BAT+", lcsc=None,
                pins={"1": "VBAT"}, back=True, note="裏側。窓から XIAO の裏の BAT+ に線でつなぐ"),
    "D1": dict(sym="Device:D", fp="Diode_SMD:D_SMA", value="M7", lcsc="C95872",
               pins={"1": "VAMP", "2": "VBUS"}, note="USB の 5V → アンプ"),
    "D2": dict(sym="Device:D_Schottky", fp="Diode_SMD:D_SOD-123", value="B5819W", lcsc="C8598",
               pins={"1": "VAMP", "2": "VBAT"}, note="電池 → アンプ"),
    # ---- 気圧センサー（切り離せる部分）
    "U3": dict(sym="shinkokyu:DPS368", fp="shinkokyu:Infineon_PG-VLGA-8-2", value="DPS368XTSA1", lcsc="C3232508",
               pins={"1": "GND", "2": "+3V3", "3": "SDA", "4": "SCL", "5": "DPS_SDO", "6": "+3V3", "7": "GND",
                     "8": "+3V3"}),
    "C4": dict(sym="Device:C", fp="Capacitor_SMD:C_0402_1005Metric", value="100nF", lcsc="C1525",
               pins={"1": "+3V3", "2": "GND"}, note="VDD"),
    "C5": dict(sym="Device:C", fp="Capacitor_SMD:C_0402_1005Metric", value="100nF", lcsc="C1525",
               pins={"1": "+3V3", "2": "GND"}, note="VDDIO"),
    "JP3": dict(sym="Jumper:SolderJumper_2_Open", fp="Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm",
                value="ADDR_0x76", lcsc=None, pins={"1": "DPS_SDO", "2": "GND"},
                note="ふだんは開けたまま（0x77）。つなぐと 0x76"),
    "J7": dict(sym="Connector_Generic:Conn_01x04", fp="Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical",
               value="TAB_WIRE", lcsc=None, hand=True, pins={"1": "+3V3", "2": "GND", "3": "SDA", "4": "SCL"},
               note="切り離したあと、ここに線をつなぐ"),
    # ---- I2C（本体側）
    "R1": dict(sym="Device:R", fp="Resistor_SMD:R_0402_1005Metric", value="4.7k", lcsc="C25900",
               pins={"1": "+3V3", "2": "SDA"}),
    "R2": dict(sym="Device:R", fp="Resistor_SMD:R_0402_1005Metric", value="4.7k", lcsc="C25900",
               pins={"1": "+3V3", "2": "SCL"}),
    "J5": dict(sym="Connector_Generic:Conn_01x04", fp="Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical",
               value="I2C_EXT", lcsc=None, hand=True, pins={"1": "+3V3", "2": "GND", "3": "SDA", "4": "SCL"},
               note="切り離したセンサーや、外付けのセンサー基板をつなぐ"),
    # ---- ボタン・予備の端子
    "SW1": dict(sym="Switch:SW_Push", fp="Button_Switch_SMD:SW_Push_1P1T_XKB_TS-1187A", value="NEXT",
                lcsc="C318884", mpn="TS-1187A-B-A-B", pins={"1": "BTN_NEXT", "2": "GND"}, note="曲送り"),
    "SW2": dict(sym="Switch:SW_Push", fp="Button_Switch_SMD:SW_Push_1P1T_XKB_TS-1187A", value="VOL+",
                lcsc="C318884", mpn="TS-1187A-B-A-B", pins={"1": "BTN_UP", "2": "GND"}, note="音量＋"),
    "SW3": dict(sym="Switch:SW_Push", fp="Button_Switch_SMD:SW_Push_1P1T_XKB_TS-1187A", value="VOL-",
                lcsc="C318884", mpn="TS-1187A-B-A-B", pins={"1": "BTN_DOWN", "2": "GND"}, note="音量−"),
    "J6": dict(sym="Connector_Generic:Conn_01x06", fp="Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical",
               value="IO", lcsc=None, hand=True,
               pins={"1": "GND", "2": "BTN_NEXT", "3": "BTN_UP", "4": "BTN_DOWN", "5": "PIEZO", "6": "IO6"},
               note="外付けのボタン・圧電ブザー（D3）・予備（D6）"),
    # ---- 確認用の端子
    "TP2": dict(sym="Connector:TestPoint", fp="TestPoint:TestPoint_Pad_D1.5mm", value="5V", lcsc=None,
                pins={"1": "VBUS"}),
}

# ---- B版：XIAO も JLCPCB が付ける。XIAO の裏の BAT+ と GND も、基板の端子に機械ではんだ付けされる
from variant import V  # noqa: E402
if V == "B":
    PARTS["U1"] = dict(sym="shinkokyu:XIAO_nRF52840_SMD", fp="shinkokyu:XIAO_nRF52840_SMD",
                       value="XIAO nRF52840", mpn="102010448", lcsc="C17209540",
                       pins=dict(PARTS["U1"]["pins"], **{"19": "VBAT", "20": "GND"}),
                       note="JLCPCB が付ける。裏の BAT+（19）と GND（20）も基板の端子にはんだ付けされる")
    del PARTS["TP1"]    # 窓から線をつなぐ端子は要らない

for _r, _p in PARTS.items():
    _p.setdefault("dnp", False)
    _p.setdefault("hand", False)
    _p.setdefault("back", False)
    _p.setdefault("note", "")

def nets():
    out = {}
    for ref, p in PARTS.items():
        for pin, n in p["pins"].items():
            out.setdefault(n, []).append((ref, pin))
    return out
